	AREA RESET,DATA,READONLY
	EXPORT __Vectors
__Vectors
	DCD 0X10001000
	DCD Reset_Handler
	ALIGN
	AREA mycode,CODE,READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R1,=NUM
	LDR R13,= 0x10001000
	BL FACT1
	LDR R1, = FACT
	STR R2,[R1]
STOP
	B STOP
FACT1
	CMP R1,#1
	BEQ EXIT
	PUSH {R1}
	PUSH {LR}
	SUB R1, R1, #1
	BL FACT1
	POP {LR}
	POP {R1}
	MUL R2,R1,R2
	BX LR
EXIT
	MOV R2,#1
	BX LR
NUM DCD 0x06
	AREA mydata, DATA,READWRITE
FACT DCD 0
	END